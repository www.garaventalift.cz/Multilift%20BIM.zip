Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], ExchangeRequirement []
Time: 2023-01-26T16:11:45
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.5.0.0 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information; sets with these values: 2

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 ft
Dimensions - Computation Height: 0 ft
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1582
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBuildingElementProxy: Multilift_Savaria:Multilift_Savaria, Multilift_Savaria:Multilift_Savaria:199088
In: Level 1
Type - Classification: D1010310 (Uniformat); Material: Metal - Color As Specified (13), Plastic - Red, Metal
Type - Analytical Model - ADA Compliant: yes; Building Code Conformance: [ASME A17.1; NFPA 70][CSA B44; CSA National Electrical Code]; Capacity (Weight): 6227.51 N
Type - Constraints - Default Elevation: 0 ft; Stops: 2
Type - Dimensions - Lift Height: 0 ft; Overhead: 0 ft; Pit Depth: 0.567708 ft; Unit Depth: 0 ft; Unit Width: 0 ft
Type - Identity Data - Assembly Code: D1010310; Copyright: 2010, ARCAT, Inc; Description: Savaria Concord Hydraulic Passenger Elevator as Specified in 14 40 00; Drawn By: Robert S. Weygant, CSI, CDT, SCIP; Keynote: 14 40 00; Manufacturer: Savaria Concord; Model: As Specified in 14 40 00; Type Name: Multilift_Savaria; URL: http://www.savariaconcord.com/
Type - Materials and Finishes - Finish: Metal - Color As Specified
Type - Other - Category: Specialty Equipment; Family Name: Multilift_Savaria; Manufacturer Address: 107 Alfred Kuehne Blvd., Brampton, ON, Canada L6T 4K3; Manufacturer Fax: 905-791-2222; Manufacturer Phone: 905-791-5555; Manufacturer Phone - Toll Free: 800-661-5112; Manufacturer Website: http://www.savariaconcord.com/; Send Message: http://www.arcat.com/users.pl?action=UserEmail&company=Savaria%20Concord&coid=31585&rep=119&fax=905-791-2222&mf=
Type - Phasing - Expected Lifespan (Years): 0; Installation Phase: Interior fixtures and fittings; Maintenance Schedule (Months): 0; Warranty Duration (Years): 1
Type - Text - Construction Details: http://www.arcat.com/details/savaria/savaria.html?coid=31585; Green Building-LEED: http://www.arcat.com/green/clients/leed_data_31585.html; Product Data: http://www.arcat.com/arcatcos/cos31/arc31585.html; Product Properties: http://www.arcat.com/bim/bim_info.pl?fn=SavariaConcord; Specification: http://www.arcat.com/sdspecs/htm/14202sci.htm; SpecWizard: http://www.arcat.com/specwizard/14202sci/index.htm?coid=31585&mf=
Type - Pset_ManufacturerTypeInformation - Manufacturer: Savaria Concord
Type - Pset_ProductRequirements - Category: Specialty Equipment
Pset_BuildingElementProxyCommon - Reference: Multilift_Savaria; sets with these values: 2
Pset_ProvisionForVoid - Width: 0.693551 ft; Height: 3.1486 ft; Depth: 0.141165 ft
Constraints - Elevation from Level: 0 ft; Host: Basic Wall : Wall 1; Mast Hight: 8.5 ft; Offset from Host: 0 ft
Construction - Has Left Door: no; Has Left Ramp: yes; Has Right Door: no; Has Right Ramp: yes; Left Door RH Swing: yes; Right Door RH Swing: yes
Dimensions - Area: 121.112 ft2; Landing 2 Elevation: 6 ft; Volume: 25.8763 ft3
Electrical - MEP Amperage: 20 A; MEP Apparent Power: 2400 W; Voltage_MEP: 120 V
Other - Family: Multilift_Savaria; Family and Type: Multilift_Savaria: Multilift_Savaria; Type: Multilift_Savaria; Type Id: 199063
Phasing - Phase Created: New Construction

# IfcDistributionPort, Port_199088
Description: Flow; FlowDirection: SOURCEANDSINK
